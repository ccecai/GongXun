# Keil uVision project mycar.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mycar +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWAR\ARM;..\HARDWAR\ENCODERCONTROL;..\HARDWAR\MOTER;..\HARDWAR\MPU9250;..\HARDWAR\PIDCONTROL;..\HARDWAR\POSITION;..\HARDWAR\SENSOR;..\HARDWAR\SPEED;..\HARDWAR\TIM;..\HARDWAR\USART1;..\USER;..\HARDWAR\FIFO;..\HARDWAR\ARMMOVE;..\HARDWAR\VALPAKAGE;..\HARDWAR\REMOTE;..\HARDWAR\KEY;..\USEFULL\IIC;..\HARDWAR\OLED_IIC;..\USEFULL\CODE;..\HARDWAR\GYROSCOPE;..\RACE;..\USEFULL\COM;..\USEFULL\TRACE;..\HARDWAR\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c main.h
    ../RACE/: runrace.c runrace.h
    ../HARDWAR/ARMMOVE/: armmove.c armmove.h
  group HARDWAR
    ../HARDWAR/ENCODERCONTROL/: encodercontrol.c encodercontrol.h
    ../HARDWAR/MOTER/: moter.c moter.h
    ../HARDWAR/PIDCONTROL/: pidcontrol.c pidcontrol.h
    ../HARDWAR/SENSOR/: sensor.c sensor.h
    ../HARDWAR/SPEED/: speedcontrol.c speedcontrol.h speedsolve.c speedsolve.h
    ../HARDWAR/POSITION/: positioncontrol.c positioncontrol.h
    ../HARDWAR/TIM/: tim6.c tim6.h tim13.c tim13.h
    ../HARDWAR/USART1/: usart.c usart.h
    ../HARDWAR/FIFO/: fifo.c fifo.h
    ../HARDWAR/REMOTE/: remotecontrol.c remotecontrol.h
    ../HARDWAR/VALPAKAGE/: valpackage.c valpackage.h
    ../HARDWAR/KEY/: key.c key.h
    ../HARDWAR/OLED_IIC/: oled.c oled.h bmp.h oledfont.h
    ../HARDWAR/GYROSCOPE/: gyroscope.c gyroscope.h
    ../HARDWAR/LED/: led.c led.h
  group USEFULL
    ../USEFULL/IIC/: myiic.c myiic.h
    ../USEFULL/COM/: comother.c comother.h
    ../USEFULL/TRACE/: trace.c trace.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../SYSTEM/delay/: delay.c
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_dac.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_fsmc.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_rng.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
